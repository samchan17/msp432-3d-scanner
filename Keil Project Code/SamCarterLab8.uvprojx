# Keil uVision project SamCarterLab8.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SamCarterLab8
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group New Group
    ./: lab8milestone2.c onboardLEDs.c onboardLEDs.h PLL.c PLL.h SysTick.c SysTick.h tm4c1294ncpdt.h uart.c uart.h vl53l1_platform_2dx4.c vl53l1_platform_2dx4.h vl53l1_types.h vl53l1_types_2dx4.h VL53L1X_api.c VL53L1X_api.h
software components: CMSIS:CORE 6.2.0, Device:Startup 3.2.3
